# Keil uVision project POV_LED.uvprojx, settings and files
target POV_LED (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: POV_LED +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DERIVER
  c include: .\RTE;.\User;..\Project;.\User\FunctionalCfg;.\User\InterfaceCfg;.\User\PeripheralCfg
  asm include: ..\Project
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./User/: main.c ReadMe.txt
  group FunctionalCfg
    ./User/FunctionalCfg/: MENU.c PAINT.c MUSIC.c SNAKE.c ATCMD.c
  group InterfaceCfg
    ./User/InterfaceCfg/: MBI5353.c ASCII.c PICTURE1.c PICTURE2.c PICTURE3.c SK9822.c
  group PeripheralCfg
    ./User/PeripheralCfg/: GPIO.c ADC.c SPI.c TIM.c USART.c
software components: CMSIS:CORE 3.40.0, Device:DMA 1.2, Device:GPIO 1.2, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
